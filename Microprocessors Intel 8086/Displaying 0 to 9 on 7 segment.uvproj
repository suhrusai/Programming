# Keil uVision project Displaying 0 to 9 on 7 segment.uvproj, settings and files
target Target 1 (MCS-51)
  device: 8051AH Intel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(12000000)
  output: Displaying help on 7 segment +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: 7 segment numbers.c
